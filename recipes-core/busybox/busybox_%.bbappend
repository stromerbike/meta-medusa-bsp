#
# Setting Busybox configuration
#

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " file://bootchart.cfg"
