
COMPATIBLE_MACHINE = "imx6ul-medusa"
COMPATIBLE_MACHINE .= "|imx6ull-medusa"
