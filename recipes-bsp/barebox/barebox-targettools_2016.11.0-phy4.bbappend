
COMPATIBLE_MACHINE = "imx6ul-medusa"
