
# Original tag v2016.08.0 is replaced with v2016.12.0
SRCREV= "31f9cb86467846d7da88720db05b44ccde9b316d"