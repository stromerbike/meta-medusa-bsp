
RDEPENDS_packagegroup-core-full-cmdline-multiuser_remove = "shadow sudo"

RDEPENDS_packagegroup-core-full-cmdline-sys-services_remove = "nfs-utils python-dbus"